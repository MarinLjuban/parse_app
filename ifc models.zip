Properties of the parts of a building model (IFC4), part 2 of 2

# IfcPipeFitting: BIMA+_Generic_Bend_Copper:Standard, BIMA+_Generic_Bend_Copper:Standard:1456142
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: HRL 1

# IfcPipeFitting: BIMA+_Generic_Bend_PVC:Standard_PVC (2)
In: Level 1
Type - PredefinedType: BEND; Classification: Pr_65_52_63_63 Number of the classified element (Number); Material: BIMA+_201_H_RL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Polyethylene (PE) water pipes and fittings Title of the classified element (Title); Pr_65_52_63_63 Number of the classified element (Number); Group: HRL 2
Name (BIMA+_Generic_Bend_PVC:Standard_PVC:...)
1457624
1457635

# IfcPipeFitting: BIMA+_Generic_Bend_PVC:Standard_PVC (29)
Type - PredefinedType: BEND; Classification: Pr_65_52_63_63 Number of the classified element (Number); Material: BIMA+_420_S_SW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Polyethylene (PE) water pipes and fittings Title of the classified element (Title); Pr_65_52_63_63 Number of the classified element (Number); Group: SW 1
Name (BIMA+_Generic_Bend_PVC:Standard_PVC:...) | In
1410497 | 2
1410510 | Level 1
1417036 | Level 1
1417558 | 2
1417566 | Level 1
1417630 | Level 1
1417648 | Level 1
1417722 | Level 1
1417726 | 1
1419129 | Level 1
1419175 | Level 1
1419223 | 9
1419343 | Level 1
1419345 | Level 1
1419570 | Level 1
1420107 | Level 1
1420111 | Level 1
1420188 | Level 1
1420496 | Level 1
1420670 | 10
1421018 | Level 1
1421449 | Level 1
1421546 | Level 1
1421612 | Level 1
1421626 | Level 1
1421630 | Level 1
1509115 | Level 1
1509120 | Level 1
1514911 | 1

# IfcPipeFitting: BIMA+_Generic_Bend_StainlessSteel:Standard (40)
In: Level 1
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_400_S_TWK
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Bend_StainlessSteel:Standard:...) | Group
1418595 | TWK 1
1418624 | TWK 1
1418675 | TWK 1
1420701 | TWK 1
1422060 | TWW 1
1422520 | TWK 1
1422585 | TWK 1
1422589 | TWK 1
1422594 | TWK 1
1422620 | TWW 1
1422638 | TWW 1
1422643 | TWW 1
1464070 | TWK 1
1464258 | TWK 1
1464341 | TWK 1
1509597 | TWK 1
1509623 | TWK 1
1509635 | TWK 1
1509643 | TWK 1
1509694 | TWW 1
1509702 | TWW 1
1509729 | TWW 1
1509737 | TWW 1
1567417 | TWK 1
1567425 | TWK 1
1567439 | TWK 1
1567441 | TWK 1
1570273 | TWW 1
1575375 | TWW 1
1575383 | TWW 1
1575397 | TWW 1
1575399 | TWW 1
1579179 | TWK 1
1579333 | TWK 1
1579458 | TWK 1
1579472 | TWK 1
1579474 | TWK 1
1579478 | TWK 1
1579498 | TWW 1
1579500 | TWW 1

# IfcPipeFitting: BIMA+_Generic_Bend_Steel:Standard (38)
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_200_H_VL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Bend_Steel:Standard:...) | In | Group
1452810 | Level 1 | HVL 1
1454042 | Level 1 | HVL 1
1454044 | Level 1 | HVL 1
1457658 | Level 1 | HVL 2
1457668 | Level 1 | HVL 2
1458047 | 6 | HVL 2
1458086 | Level 1 | HVL 2
1458250 | 6 | HRL 2
1458264 | Level 1 | HRL 2
1458266 | 6 | HRL 2
1458325 | 6 | HRL 2
1458329 | Level 1 | HRL 2
1458333 | Level 1 | HRL 2
1458422 | 6 | HVL 2
1458430 | Level 1 | HVL 2
1458432 | Level 1 | HVL 2
1465583 | Level 3 | HVL 1
1465631 | Level 3 | HVL 1
1465652 | Level 3 | HRL 1
1466254 | 3 | HRL 1
1466309 | 3 | HVL 1
1466443 | 5 | HRL 1
1466454 | 5 | HRL 1
1466458 | 5 | HVL 1
1514824 | Level 2 | HRL 1
1514847 | Level 3 | HVL 1
1514871 | 5 | HRL 1
1514888 | 5 | HVL 1
1515576 | 3 | HVL 1
1518827 | 3 | HRL 1
1518885 | 3 | HRL 1
1518893 | 3 | HRL 1
1518897 | 3 | HRL 1
1518920 | 3 | HVL 1
1518934 | 3 | HVL 1
1527826 | 5 | HRL 1
1527832 | 5 | HVL 1
1527834 | 5 | HVL 1

# IfcPipeFitting: BIMA+_Generic_Bend_Steel:Standard (17)
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_201_H_RL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Bend_Steel:Standard:...) | In | Group
1452521 | Level 1 | HRL 1
1453981 | Level 1 | HRL 1
1454024 | Level 1 | HRL 1
1454028 | Level 1 | HRL 1
1455445 | 3 | HVL 1
1455669 | 3 | HRL 1
1456702 | Level 3 | HRL 1
1456709 | Level 1 | HVL 1
1465737 | Level 2 | HRL 1
1465741 | Level 3 | HRL 1
1466445 | 5 | HRL 1
1515545 | 3 | HRL 1
1518781 | 3 | HVL 1
1518791 | 3 | HVL 1
1518819 | 3 | HRL 1
1518831 | 3 | HRL 1
1527828 | 5 | HRL 1

# IfcPipeFitting: BIMA+_Generic_Elbow_-_Generic:Standard, BIMA+_Generic_Elbow_-_Generic:Standard:1453426
In: 3
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_201_H_RL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: HRL 1

# IfcPipeFitting: BIMA+_Generic_Elbow_-_Generic:Standard (13)
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_401_S_TWW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Elbow_-_Generic:Standard:...) | In | Group
1410692 | Level 1 | TWW 1
1411688 | Level 1 | TWK 1
1411703 | Level 1 | TWK 1
1411707 | Level 1 | TWK 1
1411754 | Level 1 | TWK 1
1411773 | Level 1 | TWW 1
1415120 | Level 1 | TWK 1
1418812 | Level 1 | TWW 1
1418814 | Level 1 | TWW 1
1418827 | Level 1 | TWW 1
1419054 | Level 1 | TWW 1
1422645 | Level 1 | TWW 1
1518930 | 3 | HVL 1

# IfcPipeFitting: BIMA+_Generic_Elbow_-_Generic:Standard (9)
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_420_S_SW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Elbow_-_Generic:Standard:...) | In | Group
1413607 | Level 1 | SW 1
1415866 | Level 1 | SW 1
1416090 | Level 1 | SW 1
1416158 | 1 | SW 1
1417013 | Level 1 | SW 1
1503809 | 6 | RW 1
1504352 | 11 | RW 1
1504356 | 11 | RW 1
1519176 | 11 | RW 1

# IfcPipeFitting: BIMA+_Generic_Elbow_-_Generic:Standard (2)
In: Level 1
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_430_S_RW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: RW 1
Name (BIMA+_Generic_Elbow_-_Generic:Standard:...)
1505236
1519186

# IfcPipeFitting: BIMA+_Generic_Tee_-_Generic:Standard, BIMA+_Generic_Tee_-_Generic:Standard:1519182
In: Level 1
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_430_S_RW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: RW 1

# IfcPipeFitting: BIMA+_Generic_Tee_-_Generic:Standard (4)
In: Level 1
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_401_S_TWW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Tee_-_Generic:Standard:...) | Group
1410719 | TWW 1
1411732 | TWK 1
1415113 | TWK 1
1422597 | TWK 1

# IfcPipeFitting: BIMA+_Generic_Tee_-_Generic:Standard (3)
In: Level 1
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_420_S_SW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: SW 1
Name (BIMA+_Generic_Tee_-_Generic:Standard:...)
1415690
1416289
1505141

# IfcPipeFitting: BIMA+_Generic_Tee_-_Generic:Standard, BIMA+_Generic_Tee_-_Generic:Standard:1504103
In: 6
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_430_S_RW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: RW 1

# IfcPipeFitting: BIMA+_Generic_Tee_PVC:Standard (2)
In: Level 1
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_63 Number of the classified element (Number); Material: BIMA+_401_S_TWW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Polyethylene (PE) water pipes and fittings Title of the classified element (Title); Pr_65_52_63_63 Number of the classified element (Number); Group: TWW 1
Name (BIMA+_Generic_Tee_PVC:Standard:...)
1418986
1422198

# IfcPipeFitting: BIMA+_Generic_Tee_PVC:Standard (5)
In: Level 1
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_63 Number of the classified element (Number); Material: BIMA+_420_S_SW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Polyethylene (PE) water pipes and fittings Title of the classified element (Title); Pr_65_52_63_63 Number of the classified element (Number); Group: SW 1
Name (BIMA+_Generic_Tee_PVC:Standard:...)
1419257
1419465
1420183
1421013
1421576

# IfcPipeFitting: BIMA+_Generic_Tee_StainlessSteel:Tee_StainlessSteel (4)
In: Level 1
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_400_S_TWK
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: TWK 1
Name (BIMA+_Generic_Tee_StainlessSteel:Tee_StainlessSteel:...)
1418619
1418671
1419073
1463745

# IfcPipeFitting: BIMA+_Generic_Tee_Steel:Standard (8)
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_200_H_VL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Tee_Steel:Standard:...) | In | Group
1437102 | 3 | HVL 1
1455505 | 3 | HRL 1
1456030 | Level 3 | HVL 1
1456036 | Level 2 | HRL 1
1457143 | Level 1 | HVL 2
1457359 | Level 1 | HRL 2
1466242 | 3 | HRL 1
1466301 | 3 | HVL 1

# IfcPipeFitting: BIMA+_Generic_Tee_Steel:Standard (4)
Type - PredefinedType: JUNCTION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_201_H_RL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Tee_Steel:Standard:...) | In | Group
1456004 | Level 2 | HRL 1
1456020 | Level 3 | HVL 1
1456429 | 5 | HVL 1
1456567 | 5 | HRL 1

# IfcPipeFitting: BIMA+_Generic_Transition_-_Generic:Standard (2)
In: Level 1
Type - PredefinedType: TRANSITION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_420_S_SW
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Transition_-_Generic:Standard:...) | Group
1420846 | SW 1
1505150 | SW 1; RW 1

# IfcPipeFitting: BIMA+_Generic_Transition_Copper_StainlessSteel:Standard, BIMA+_Generic_Transition_Copper_StainlessSteel:Standard:1579176
In: Level 1
Type - PredefinedType: TRANSITION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_400_S_TWK
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: TWK 1

# IfcPipeFitting: BIMA+_Generic_Transition_Steel_Symmetry:Standard (6)
Type - PredefinedType: TRANSITION; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_200_H_VL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number)
Name (BIMA+_Generic_Transition_Steel_Symmetry:Standard:...) | In | Group
1456195 | Level 3 | HVL 1
1456691 | 5 | HRL 1
1456713 | 5 | HVL 1
1458090 | Level 1 | HVL 2
1458262 | Level 1 | HRL 2
1515613 | 3 | HVL 1

# IfcPipeSegment: Pipe Types:BIMA+_Generic_PVC_U (66)
In: Level 1
Type - PredefinedType: RIGIDSEGMENT; Material: BIMA+_420_S_SW
Type - IfcRoot - IfcDescription: A pipe segment is used to typically join two sections of a piping network.
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Unplasticized polyvinyl chloride (PVC-U) pipes Title of the classified element (Title); Pr_65_52_63_89 Number of the classified element (Number)
Name (Pipe Types:BIMA+_Generic_PVC_U:...) | Length (mm) | GrossCrossSectionArea (m2) | NominalDiameter (mm) | Group
1410472 | 49 | 0.0076969 | 50 | SW 1
1410491 | 139.214 | 0.0218677 | 50 | SW 1
1413392 | 131.148 | 0.0206007 | 50 | SW 1
1413465 | 433.668 | 0.136241 | 100 | SW 1
1413563 | 55.269 | 0.00868164 | 50 | SW 1
1415833 | 5.39998 | 0.000848227 | 50 | SW 1
1416066 | 98.2929 | 0.0154398 | 50 | SW 1
1416076 | 159.132 | 0.0249964 | 50 | SW 1
1416138 | 55.0898 | 0.00865348 | 50 | SW 1
1416177 | 4829.37 | 1.51719 | 100 | SW 1
1416217 | 1132.05 | 0.177822 | 50 | SW 1
1416267 | 65.8376 | 0.0165468 | 80 | SW 1
1416346 | 1167.17 | 0.183338 | 50 | SW 1
1416897 | 44.6208 | 0.00700902 | 50 | SW 1
1416997 | 209.122 | 0.0328487 | 50 | SW 1
1417009 | 29.1705 | 0.00458209 | 50 | SW 1
1417288 | 496.982 | 0.0780657 | 50 | SW 1
1417296 | 98.5511 | 0.0154804 | 50 | SW 1
1417624 | 49 | 0.0076969 | 50 | SW 1
1417626 | 139.29 | 0.0218796 | 50 | SW 1
1417642 | 496.608 | 0.078007 | 50 | SW 1
1417644 | 303.66 | 0.0476988 | 50 | SW 1
1419110 | 100.417 | 0.0157734 | 50 | SW 1
1419125 | 86.0367 | 0.0135146 | 50 | SW 1
1419134 | 348.194 | 0.0546941 | 50 | SW 1
1419159 | 100.683 | 0.0158152 | 50 | SW 1
1419171 | 84.9045 | 0.0133368 | 50 | SW 1
1419180 | 79.5839 | 0.012501 | 50 | SW 1
1419204 | 96.0662 | 0.01509 | 50 | SW 1
1419217 | 316.539 | 0.0497219 | 50 | SW 1
1419236 | 312.621 | 0.0491063 | 50 | SW 1
1419304 | 792.585 | 0.124499 | 50 | SW 1
1419362 | 156.066 | 0.0245148 | 50 | SW 1
1419480 | 792.641 | 0.124508 | 50 | SW 1
1419678 | 632.713 | 0.159018 | 80 | SW 1
1420092 | 55.1273 | 0.00865938 | 50 | SW 1
1420168 | 184.879 | 0.0290407 | 50 | SW 1
1420184 | 9.35131 | 0.0014689 | 50 | SW 1
1420482 | 242.172 | 0.0380402 | 50 | SW 1
1420651 | 309.29 | 0.0485831 | 50 | SW 1
1420986 | 82.2014 | 0.0206595 | 80 | SW 1
1421014 | 105.913 | 0.0166367 | 50 | SW 1
1421428 | 9839.37 | 2.4729 | 80 | SW 1
1421535 | 10259.5 | 2.57848 | 80 | SW 1
1421550 | 12461.1 | 4.89346 | 125 | SW 1
1421608 | 195.743 | 0.0614944 | 100 | SW 1
1439570 | 288.319 | 0.0181156 | 20 | HRL 2
1439598 | 4.5 | 0.000212058 | 15 | HRL 2
1457224 | 5243.79 | 0.247108 | 15 | HVL 2
1457548 | 236.681 | 0.0148711 | 20 | HRL 2
1457622 | 314 | 0.0197292 | 20 | HRL 2
1503785 | 2026.97 | 0.318396 | 50 | RW 1
1503805 | 15.4 | 0.00241902 | 50 | RW 1
1504090 | 9.04999 | 0.00142157 | 50 | RW 1
1504104 | 3606.98 | 0.566582 | 50 | RW 1
1504291 | 15.4 | 0.00241902 | 50 | RW 1
1504304 | 133.638 | 0.0209917 | 50 | RW 1
1504346 | 413.325 | 0.0649249 | 50 | RW 1
1504434 | 9500.7 | 1.49237 | 50 | RW 1
1504535 | 10165.8 | 1.59684 | 50 | SW 1; RW 1
1504858 | 20.0342 | 0.00629394 | 100 | SW 1
1505112 | 3620.08 | 0.56864 | 50 | RW 1
1505142 | 3157.3 | 0.991896 | 100 | SW 1
1509111 | 57.6126 | 0.0226244 | 125 | SW 1
1509112 | 43.7526 | 0.0171816 | 125 | SW 1
1519183 | 4220.31 | 0.662925 | 50 | RW 1

# IfcPipeSegment: Pipe Types:BIMA+_Generic_Stainless_Steel (75)
In: Level 1
Type - PredefinedType: RIGIDSEGMENT; Material: BIMA+_401_S_TWW
Type - IfcRoot - IfcDescription: A pipe segment is used to typically join two sections of a piping network.
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Steel Pipes Title of the classified element (Title); Pr_65_52_63_82 Number of the classified element (Number)
Name (Pipe Types:BIMA+_Generic_Stainless_Steel:...) | Length (mm) | GrossCrossSectionArea (m2) | NominalDiameter (mm) | Group
1410443 | 50.7125 | 0.00238977 | 15 | TWW 1
1410537 | 1387.78 | 0.0653976 | 15 | TWW 1
1410671 | 50.7125 | 0.00238977 | 15 | TWW 1
1410703 | 205.787 | 0.0096975 | 15 | TWW 1
1410720 | 1382.37 | 0.0651427 | 15 | TWW 1
1410731 | 50.7125 | 0.00238977 | 15 | TWK 1
1410790 | 50.7125 | 0.00238977 | 15 | TWK 1
1411534 | 1667.78 | 0.0785923 | 15 | TWK 1
1411686 | 55.6874 | 0.0026242 | 15 | TWK 1
1411699 | 55.6874 | 0.0026242 | 15 | TWK 1
1411733 | 1662.37 | 0.0783374 | 15 | TWK 1
1411786 | 859.716 | 0.0405132 | 15 | TWK 1
1411815 | 1309.65 | 0.0617157 | 15 | TWW 1
1413762 | 237.625 | 0.0111978 | 15 | TWK 1
1415097 | 182.126 | 0.00858251 | 15 | TWK 1
1415114 | 176.565 | 0.00832045 | 15 | TWK 1
1418238 | 189.358 | 0.00892327 | 15 | TWK 1
1418346 | 189.022 | 0.00890743 | 15 | TWK 1
1418575 | 192 | 0.00904779 | 15 | TWK 1
1418589 | 724.457 | 0.0341392 | 15 | TWK 1
1418617 | 120.755 | 0.00569046 | 15 | TWK 1
1418620 | 730.429 | 0.0344207 | 15 | TWK 1
1418669 | 118.577 | 0.0055878 | 15 | TWK 1
1418672 | 379 | 0.01786 | 15 | TWK 1
1418700 | 178.842 | 0.00842773 | 15 | TWK 1
1418754 | 205.713 | 0.00969397 | 15 | TWW 1
1418774 | 1467.96 | 0.0691758 | 15 | TWW 1
1418795 | 205.906 | 0.00970307 | 15 | TWW 1
1418810 | 71.425 | 0.00336582 | 15 | TWW 1
1418823 | 68.2125 | 0.00321444 | 15 | TWW 1
1418913 | 271.755 | 0.0128062 | 15 | TWW 1
1419089 | 425.5 | 0.0200512 | 15 | TWK 1
1420693 | 1739 | 0.0819484 | 15 | TWK 1
1421664 | 1852.71 | 0.087307 | 15 | TWW 1
1421807 | 502.614 | 0.0236851 | 15 | TWK 1
1421944 | 7989.5 | 0.376496 | 15 | TWW 1
1421970 | 7851.73 | 0.370004 | 15 | TWK 1
1421981 | 6339.95 | 0.298763 | 15 | TWK 1
1421984 | 452.999 | 0.0213471 | 15 | TWK 1
1422077 | 6528.57 | 0.307652 | 15 | TWW 1
1422203 | 424.506 | 0.0200044 | 15 | TWW 1
1422392 | 861.823 | 0.0406124 | 15 | TWK 1
1422508 | 107.083 | 0.00504617 | 15 | TWK 1
1422579 | 4.77726 | 0.000225123 | 15 | TWK 1
1422580 | 12.3188 | 0.000580512 | 15 | TWK 1
1422598 | 246.901 | 0.0116349 | 15 | TWK 1
1422630 | 386.733 | 0.0182244 | 15 | TWW 1
1422631 | 23.6646 | 0.00111517 | 15 | TWW 1
1463746 | 34.9524 | 0.00219612 | 20 | TWK 1
1464042 | 19.3474 | 0.000911725 | 15 | TWK 1
1464066 | 5.01457 | 0.000236306 | 15 | TWK 1
1464247 | 38.9303 | 0.00183455 | 15 | TWK 1
1464333 | 20.3711 | 0.000959965 | 15 | TWK 1
1509559 | 7470.17 | 0.469365 | 20 | TWK 1
1509566 | 7406.03 | 0.349001 | 15 | TWW 1
1509600 | 47 | 0.0029531 | 20 | TWK 1
1509617 | 4342 | 0.272816 | 20 | TWK 1
1509627 | 119.5 | 0.00750841 | 20 | TWK 1
1509637 | 4971 | 0.312337 | 20 | TWK 1
1509681 | 49 | 0.00230907 | 15 | TWW 1
1509706 | 4284 | 0.201879 | 15 | TWW 1
1509721 | 181.5 | 0.00855299 | 15 | TWW 1
1509731 | 4972 | 0.2343 | 15 | TWW 1
1567361 | 353 | 0.0166347 | 15 | TWK 1
1567405 | 9 | 0.000424115 | 15 | TWK 1
1567419 | 33 | 0.00155509 | 15 | TWK 1
1567427 | 9 | 0.000424115 | 15 | TWK 1
1570151 | 3136.37 | 0.147798 | 15 | TWK 1
1570163 | 3141.61 | 0.148045 | 15 | TWW 1
1570187 | 84 | 0.00395841 | 15 | TWK 1
1570238 | 84 | 0.00395841 | 15 | TWW 1
1575261 | 1445.14 | 0.0681007 | 15 | TWW 1
1575359 | 9.19302 | 0.000433211 | 15 | TWW 1
1575377 | 33 | 0.00155509 | 15 | TWW 1
1575385 | 9.19302 | 0.000433211 | 15 | TWW 1

# IfcPipeSegment: Pipe Types:BIMA+_Generic_Steel (85)
Type - PredefinedType: RIGIDSEGMENT; Material: BIMA+_200_H_VL
Type - IfcRoot - IfcDescription: A pipe segment is used to typically join two sections of a piping network.
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Steel Pipes Title of the classified element (Title); Pr_65_52_63_82 Number of the classified element (Number)
Name (Pipe Types:BIMA+_Generic_Steel:...) | In | Length (mm) | GrossCrossSectionArea (m2) | NominalDiameter (mm) | Group
1433793 | Level 1 | 1172.41 | 0.117864 | 32 | HVL 1
1433830 | Level 1 | 1218.91 | 0.0765862 | 20 | HRL 1
1433844 | Level 1 | 333.998 | 0.0209857 | 20 | HRL 1
1433869 | Level 1 | 298 | 0.0299582 | 32 | HVL 1
1433921 | Level 1 | 3401.87 | 0.341993 | 32 | HVL 1
1433941 | Level 1 | 3367 | 0.211555 | 20 | HVL 1
1434170 | Level 1 | 3322.01 | 0.208728 | 20 | HRL 1
1434904 | Level 1 | 3455.03 | 0.217086 | 20 | HRL 1
1435128 | Level 1 | 7399 | 0.464893 | 20 | HRL 1
1435169 | Level 1 | 7324 | 0.736289 | 32 | HVL 1
1435561 | Level 2 | 116.812 | 0.00550463 | 15 | HRL 1
1435584 | Level 2 | 1737.13 | 0.0818601 | 15 | HRL 1
1435608 | Level 3 | 228.812 | 0.0107825 | 15 | HVL 1
1437053 | Level 1 | 1091.08 | 0.0514159 | 15 | HVL 1
1439622 | Level 1 | 3.1 | 0.000146084 | 15 | HVL 2
1440187 | Level 3 | 719.25 | 0.0451918 | 20 | HVL 1
1449829 | Level 4 | 82 | 0.00386416 | 15 | HVL 1
1449833 | Level 4 | 57 | 0.00268606 | 15 | HRL 1
1449835 | Level 4 | 4469.69 | 0.210629 | 15 | HRL 1
1450959 | Level 1 | 2884 | 0.289931 | 32 | HVL 1
1451430 | Level 2 | 372 | 0.0233734 | 20 | HRL 1
1451508 | Level 1 | 309 | 0.0310641 | 32 | HVL 1
1451811 | Level 2 | 95.7125 | 0.00451035 | 15 | HVL 1
1451835 | Level 2 | 7 | 0.000329867 | 15 | HRL 1
1453209 | Level 1 | 28.5375 | 0.00179306 | 20 | HRL 1
1453493 | Level 1 | 10 | 0.000471239 | 15 | HRL 1
1453545 | Level 1 | 810.188 | 0.0509056 | 20 | HRL 1
1455401 | Level 1 | 760.188 | 0.047764 | 20 | HVL 1
1455506 | Level 1 | 123.812 | 0.00777933 | 20 | HRL 1
1455821 | Level 3 | 1007.37 | 0.047471 | 15 | HVL 1
1455825 | Level 3 | 37 | 0.00174358 | 15 | HVL 1
1455827 | Level 3 | 7 | 0.000329867 | 15 | HRL 1
1455831 | Level 2 | 1064.01 | 0.0501405 | 15 | HRL 1
1455843 | Level 4 | 1007.37 | 0.047471 | 15 | HVL 1
1455847 | Level 4 | 82 | 0.00386416 | 15 | HVL 1
1455849 | Level 4 | 7 | 0.000329867 | 15 | HRL 1
1455853 | Level 3 | 1064.01 | 0.0501405 | 15 | HRL 1
1456005 | Level 2 | 814.188 | 0.0383677 | 15 | HRL 1
1456021 | Level 3 | 2.93815 | 0.000138457 | 15 | HVL 1
1456031 | Level 1 | 2949.5 | 0.185323 | 20 | HVL 1
1456037 | Level 1 | 2994.5 | 0.18815 | 20 | HRL 1
1456323 | Level 3 | 548.812 | 0.0258621 | 15 | HVL 1
1456348 | Level 3 | 4728.1 | 0.222806 | 15 | HVL 1
1456430 | Level 3 | 722.188 | 0.0453764 | 20 | HVL 1
1456476 | Level 3 | 448.812 | 0.0211498 | 15 | HRL 1
1456568 | Level 3 | 772.188 | 0.048518 | 20 | HRL 1
1456887 | Level 1 | 809.858 | 0.0381637 | 15 | HVL 2
1456971 | Level 1 | 975.894 | 0.0459879 | 15 | HVL 2
1457002 | Level 1 | 810.505 | 0.0381942 | 15 | HRL 2
1457068 | Level 1 | 166.318 | 0.0167201 | 32 | HVL 2
1457263 | Level 1 | 4.20851 | 0.000198321 | 15 | HRL 2
1457304 | Level 1 | 4 | 0.000188496 | 15 | HVL 2
1457511 | Level 1 | 209.682 | 0.0210796 | 32 | HVL 2
1457656 | Level 1 | 224 | 0.0225189 | 32 | HVL 2
1458039 | Level 1 | 878.37 | 0.0413922 | 15 | HVL 2
1458170 | Level 1 | 5175 | 0.243866 | 15 | HRL 2
1458186 | Level 1 | 936.04 | 0.0441098 | 15 | HRL 2
1458203 | Level 1 | 25.6473 | 0.0012086 | 15 | HRL 2
1458312 | Level 1 | 874.494 | 0.0412096 | 15 | HRL 2
1458323 | Level 1 | 936.04 | 0.0441098 | 15 | HRL 2
1458420 | Level 1 | 878.37 | 0.0413922 | 15 | HVL 2
1465413 | Level 3 | 32 | 0.00150796 | 15 | HRL 1
1465533 | Level 3 | 7 | 0.000329867 | 15 | HVL 1
1465558 | Level 3 | 2606.72 | 0.122839 | 15 | HVL 1
1465644 | Level 3 | 588.314 | 0.0277236 | 15 | HRL 1
1465692 | Level 3 | 205.131 | 0.00966658 | 15 | HRL 1
1465844 | Level 2 | 12 | 0.000565487 | 15 | HVL 1
1465875 | Level 2 | 12 | 0.000565487 | 15 | HRL 1
1466240 | Level 2 | 18 | 0.00084823 | 15 | HRL 1
1466243 | Level 1 | 3063.54 | 0.192488 | 20 | HRL 1
1466302 | Level 1 | 223.812 | 0.0140625 | 20 | HVL 1
1466439 | Level 3 | 17.2119 | 0.00081109 | 15 | HRL 1
1466440 | Level 4 | 47.5147 | 0.00223908 | 15 | HRL 1
1518642 | Level 2 | 30 | 0.00141372 | 15 | HVL 1
1518650 | Level 1 | 1154.01 | 0.0543816 | 15 | HRL 1
1518732 | Level 1 | 2409.56 | 0.113548 | 15 | HVL 1
1518752 | Level 1 | 2353.92 | 0.110926 | 15 | HRL 1
1518777 | Level 1 | 120.462 | 0.00567664 | 15 | HVL 1
1518778 | Level 1 | 51.0503 | 0.00240569 | 15 | HVL 1
1518815 | Level 2 | 120.462 | 0.00567664 | 15 | HRL 1
1518816 | Level 2 | 51.0503 | 0.00240569 | 15 | HRL 1
1518883 | Level 1 | 36.5 | 0.00172002 | 15 | HRL 1
1518918 | Level 2 | 36.5 | 0.00172002 | 15 | HVL 1
1527786 | Level 4 | 4631.04 | 0.218233 | 15 | HRL 1
1527808 | Level 3 | 4419.69 | 0.208273 | 15 | HVL 1

# IfcSanitaryTerminal: BIMA+_Berger_Toilet_BurrRidge:Elongated Ergo Height (4)
In: Level 1
Type - PredefinedType: WCSEAT; Classification: Pr_40_20_93_97 Number of the classified element (Number); Material: BIMA+_Porcelain, <Unnamed>, BIMA+_Metal Chrome
Type - IfcRoot - IfcDescription: Water Closet
Type - PSet_ManufacturerTypeInformation - Manufacturer: Berger
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); WC suites Title of the classified element (Title); Pr_40_20_93_97 Number of the classified element (Number); Group: SW 1; TWK 1
Name (BIMA+_Berger_Toilet_BurrRidge:Elongated Ergo Height:...)
1411970
1413706
1415183
1415484

# IfcSanitaryTerminal: BIMA+_Geberit_PlumbingFixture_Washbasin_Vertical:505.021.01.6 (4)
Type - PredefinedType: WASHHANDBASIN; Classification: Pr_40_20_96_96 Number of the classified element (Number); Material: BIMA+_BIMAp_GEB_Ceramic, BIMA+_420_S_SW
Type - IfcRoot - IfcDescription: Washbasin
Type - PSet_ManufacturerTypeInformation - Manufacturer: Geberit
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Wall-hung washbasins Title of the classified element (Title); Pr_40_20_96_96 Number of the classified element (Number); Group: SW 1
Name (BIMA+_Geberit_PlumbingFixture_Washbasin_Vertical:505.021.01.6:...) | In
1408222 | 1
1410193 | 2
1415496 | 9
1418562 | 10

# IfcUnitaryEquipment: BIMA+_Kampmann_TrenchHeating_2pipe:HK320 (2)
In: 6
Type - PredefinedType: AIRHANDLER; Classification: Pr_70_65_03_25 Number of the classified element (Number); Material: BIMA+_MC_210_210_210_0_50 (2), BIMA+_MC_152_152_152_0_50
Type - IfcRoot - IfcDescription: Fan Coil
Type - PSet_ManufacturerTypeInformation - Manufacturer: Kampmann
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Dry air coolers Title of the classified element (Title); Pr_70_65_03_25 Number of the classified element (Number); Material: BIMA+_MC_210_210_210_0_50, BIMA+_MC_152_152_152_0_50; Group: HRL 2; HVL 2
Name (BIMA+_Kampmann_TrenchHeating_2pipe:HK320:...)
1427396
1427453

# IfcUnitaryEquipment: BIMA+_Kapmann_FanCoil_Ceiling:1250x495_TopConnection (6)
Type - PredefinedType: AIRHANDLER; Classification: Pr_70_65_03_25 Number of the classified element (Number); Material: <Unnamed>
Type - IfcRoot - IfcDescription: Fan Coil
Type - PSet_ManufacturerTypeInformation - Manufacturer: Kampmann
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Dry air coolers Title of the classified element (Title); Pr_70_65_03_25 Number of the classified element (Number); Group: HVL 1; HRL 1
Name (BIMA+_Kapmann_FanCoil_Ceiling:1250x495_TopConnection:...) | In
1449395 | 3
1449810 | Level 3
1449828 | 5
1455760 | Level 3
1455762 | 5
1465808 | 3

# IfcUnitaryEquipment: BIMo_Clivet_VRF_Outdoor_MV6i_500T:MV6-i500WV2GN1 (2)
In: Level 1
Type - PredefinedType: ROOFTOPUNIT; Classification: Pr_70_60_37_04 Number of the classified element (Number); Material: BIMA+_Galvanized Steel, <Unnamed>
Type - IfcRoot - IfcDescription: Outdoor Unit
Type - PSet_ManufacturerTypeInformation - Manufacturer: Clivet
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Air-to-air heat pumps Title of the classified element (Title); Pr_70_60_37_04 Number of the classified element (Number)
Name (BIMo_Clivet_VRF_Outdoor_MV6i_500T:MV6-i500WV2GN1:...) | Group
1403313 | HVL 1; HRL 1
1439442 | HRL 2; HVL 2

# IfcValve: BIMA+_Geberit_WashbasinTap_Brenta:DeckMounted_15mm (4)
Type - PredefinedType: FAUCET; Classification: Pr_40_20_87_84 Number of the classified element (Number); Material: BIMA+_BIMAp_GEB_StainlessSteel
Type - IfcRoot - IfcDescription: Sanitary faucet
Type - PSet_ManufacturerTypeInformation - Manufacturer: Geberit
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Sink taps Title of the classified element (Title); Pr_40_20_87_84 Number of the classified element (Number); Group: TWW 1; TWK 1
Name (BIMA+_Geberit_WashbasinTap_Brenta:DeckMounted_15mm:...) | In
1410083 | 1
1410194 | 2
1415497 | 9
1418563 | 10

# IfcWasteTerminal: BIMA+_Geberit_PlumbingFixture_Pluvia:125/50 (3)
In: Level 2
Type - PredefinedType: ROOFDRAIN; Classification: Pr_65_50_35_81 Number of the classified element (Number); Material: BIMA+_430_S_RW
Type - IfcRoot - IfcDescription: Rainwater Drain
Type - PSet_ManufacturerTypeInformation - Manufacturer: Geberit
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Siphonic rainwater outlets Title of the classified element (Title); Pr_65_50_35_81 Number of the classified element (Number); Group: RW 1
Name (BIMA+_Geberit_PlumbingFixture_Pluvia:125/50:...)
1503360
1503369
1503386
