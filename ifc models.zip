Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [BuildingService]
File name: Project Number
Time: 2022-11-21T20:02:36+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Alternate UI 23.0.1.318

# IfcProject, Project Number
LongName: Project Name; Phase: Approved

# IfcSite, Default
RefLatitude: 1, 46, 0, 24406; RefLongitude: 0, -7, -15, -771935; RefElevation: -3.46517e-11 mm

# IfcBuildingStorey: Level:8mm Head (4)
Name | LongName | Elevation (mm)
Level 1 | Level 1 | 177562
Level 2 | Level 2 | 180562
Level 3 | Level 3 | 183562
Level 4 | Level 4 | 186562

# IfcSpace: Entrance Hall 11:1570002, 11
In: Level 1
Type - PredefinedType: SPACE
LongName: Entrance Hall
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Exhibition Room 6:1420744, 6
In: Level 1
Type - PredefinedType: SPACE
LongName: Exhibition Room
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Exhibition space 3:1420747, 3
In: Level 1
Type - PredefinedType: SPACE
LongName: Exhibition space
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0; AirConditioning: no; AirConditioningCentral: no; DiscontinuedHeating: 0

# IfcSpace: Mezzanine L3 5:1570044, 5
In: Level 3
Type - PredefinedType: SPACE
LongName: Mezzanine L3
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Space 7:1570016, 7
In: Level 2
Type - PredefinedType: SPACE
LongName: Space
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Toilet 1 1:1420750, 1
In: Level 1
Type - PredefinedType: SPACE
LongName: Toilet 1
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Toilet 2 2:1420753, 2
In: Level 1
Type - PredefinedType: SPACE
LongName: Toilet 2
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Toilet 3 9:1420738, 9
In: Level 1
Type - PredefinedType: SPACE
LongName: Toilet 3
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; NetPlannedArea: 1 m2; PubliclyAccessible: yes
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcSpace: Toilet 4 10:1420741, 10
In: Level 1
Type - PredefinedType: SPACE
LongName: Toilet 4
PSet_SpaceCommon - NaturalVentilation: yes; NaturalVentilationRate: 1; PubliclyAccessible: yes; NetPlannedArea: 1 m2
PSet_SpaceThermalDesign - CoolingDesignAirflow: no; CoolingDryBulb: 0; CoolingRelativeHumidity: 0; TotalHeatGain: 0; TotalHeatLoss: 0; TotalSensibleHeatGain: 0; VentilationAirFlowrate: 0
PSet_SpaceThermalRequirements - SpaceHumidityMin: 0; SpaceHumidityMax: 0; SpaceHumidityWinter: 0; SpaceHumiditySummer: 0; SpaceHumidity: 0; SpaceTemperatureMin: 0; SpaceTemperatureMax: 0; SpaceTemperature: 0; SpaceTemperatureWinter: 0; SpaceTemperatureWinterMax: 0; SpaceTemperatureWinterMin: 0

# IfcAirTerminal: BIMA+_Generic_PoppetValve_Round_Exhaust:NW 100 (4)
Type - PredefinedType: REGISTER; Classification: Pr_70_65_04_02 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Type - IfcRoot - IfcDescription: Poppet Valve
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Description: IfcFlowController; Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Air diffusers Title of the classified element (Title); Pr_70_65_04_02 Number of the classified element (Number)
Name (BIMA+_Generic_PoppetValve_Round_Exhaust:NW 100:...) | In | Group
1476981 | 9 | ETA 1
1494875 | 10 | ETA 1
1505259 | 2 | ETA 2
1505274 | 1 | ETA 2

# IfcAirTerminal: BIMA+_Klimaoprema_AirTerminal_OAH1:425x125, BIMA+_Klimaoprema_AirTerminal_OAH1:425x125:1506148
In: Level 1
Type - PredefinedType: GRILLE; Classification: Pr_70_65_04_03 Number of the classified element (Number); Material: BIMA+_120_L_ETA, BIMA+_Aluminum
Type - IfcRoot - IfcDescription: Air Grille
Type - PSet_ManufacturerTypeInformation - Manufacturer: Klimaoprema
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Air terminals Title of the classified element (Title); Pr_70_65_04_03 Number of the classified element (Number); Group: ETA 2

# IfcAirTerminal: BIMA+_Klimaoprema_AirTerminal_OAH1:425x325, BIMA+_Klimaoprema_AirTerminal_OAH1:425x325:1484360
In: Level 2
Type - PredefinedType: GRILLE; Classification: Pr_70_65_04_03 Number of the classified element (Number); Material: BIMA+_120_L_ETA, BIMA+_Aluminum
Type - IfcRoot - IfcDescription: Air Grille
Type - PSet_ManufacturerTypeInformation - Manufacturer: Klimaoprema
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Air terminals Title of the classified element (Title); Pr_70_65_04_03 Number of the classified element (Number); Group: ETA 1

# IfcDistributionPort (982)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_1403313 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1433869 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1403313 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1433844 | SOURCEANDSINK | PIPE | HEATING | HRL 1
Port_1403313 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1417624 | SINK | PIPE | SEWAGE | SW 1
OutPort_1408222 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1410083 | SINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1410671 | SOURCE | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410083 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1410790 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1410472 | SINK | PIPE | SEWAGE | SW 1
OutPort_1410193 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1410194 | SINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1410443 | SOURCE | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410194 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1410731 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1410443 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1411773 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410472 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1410497 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1410491 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1410510 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1410510 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1417288 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1410537 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1410692 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1410719 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410671 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1410703 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1422645 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410719 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1410720 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410720 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1410731 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411754 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1410790 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411688 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411707 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411534 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411534 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1411732 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411688 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411686 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411686 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411707 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411754 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411699 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411699 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411703 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411703 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411733 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411733 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411732 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422598 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1411786 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422594 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422597 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1411786 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1411815 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1422643 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1416138 | SINK | PIPE | SEWAGE | SW 1
OutPort_1411970 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1411970 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1415097 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1413392 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1416158 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1413607 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1413465 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421013 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421626 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1413563 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1415690 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1416066 | SINK | PIPE | SEWAGE | SW 1
OutPort_1413706 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1413706 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1415114 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1413762 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1415120 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1415113 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1413762 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1415097 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1415113 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1415114 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1415120 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1421807 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1419171 | SINK | PIPE | SEWAGE | SW 1
OutPort_1415183 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1415183 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418346 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1419125 | SINK | PIPE | SEWAGE | SW 1
OutPort_1415484 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1415484 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418238 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1419204 | SINK | PIPE | SEWAGE | SW 1
OutPort_1415496 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1415497 | SINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1418795 | SOURCE | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1415497 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418575 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1415690 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1415833 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421014 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1415833 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1415866 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1415866 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1416076 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1416066 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1416090 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1416076 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1416138 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1416177 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421630 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1416217 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417722 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417726 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1416267 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421018 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420846 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
3 x InPort_1416289 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1417009 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1416897 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1416346 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417036 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417558 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1416897 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1416997 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417013 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1417009 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1417288 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417566 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1417296 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1417624 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1514911 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1417626 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1417630 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1417630 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1417642 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1417642 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1417648 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1417644 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1418238 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418675 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418346 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418624 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1419362 | SINK | PIPE | SEWAGE | SW 1
OutPort_1418562 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1418563 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418700 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418563 | SINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1418754 | SOURCE | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1418575 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418595 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418589 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1419073 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418671 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418589 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418595 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418620 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418617 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1418619 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418624 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418617 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418620 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418619 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567361 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418675 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418669 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418669 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1418671 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418672 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567439 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1418672 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418700 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1418754 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1418827 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1418774 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1575397 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
3 x OutPort_1418986 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1418795 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1418812 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1418810 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1418814 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1418814 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1575261 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1418823 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1418913 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1419054 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1419054 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1421664 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1419073 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1419089 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1419089 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1420701 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1419110 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419129 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419465 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419125 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419134 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420188 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419159 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419257 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419175 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419171 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419180 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420111 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419204 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419223 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419217 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419343 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419236 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1419345 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419257 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1419304 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419304 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419362 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420670 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419465 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1419480 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419480 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1419570 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1419570 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1420482 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1419678 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421449 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420183 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1420092 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1420107 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420107 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1420184 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1420168 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420183 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420482 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1420496 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420496 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1420651 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420651 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1420701 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1420693 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1420693 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579179 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1420986 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1421013 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1421428 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1421546 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1421535 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1421576 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
Port_1421550 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1421550 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1509120 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1421576 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1509111 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1504858 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1421608 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1421612 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1421612 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1505142 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1421664 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1422060 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1421807 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1422597 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1421944 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1422198 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1422620 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1421970 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579333 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579474 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1421970 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579179 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1421981 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1421981 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579176 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1421984 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579472 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579458 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1421984 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422060 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1422077 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1422077 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1422198 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1509566 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1422203 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1579498 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1579500 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1422392 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579458 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422520 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422392 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422585 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422508 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422508 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422520 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422579 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422585 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422589 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422579 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422580 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422589 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422594 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1422580 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422598 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1422620 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1570163 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1422630 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1422638 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1422631 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
Port_1427396 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1439598 | SINK | PIPE | HEATING | HRL 2
OutPort_1427396 | SOURCE | PIPE | HEATING | HRL 2
InPort_1427396 | SINK | PIPE | HEATING | HVL 2
OutPort_1439622 | SOURCE | PIPE | HEATING | HVL 2
Port_1427453 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1457263 | SINK | PIPE | HEATING | HRL 2
OutPort_1427453 | SOURCE | PIPE | HEATING | HRL 2
InPort_1427453 | SINK | PIPE | HEATING | HVL 2
OutPort_1457304 | SOURCE | PIPE | HEATING | HVL 2
2 x InPort_1433793 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1454044 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1454042 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1433830 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1454024 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1453981 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1433844 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1433869 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1433921 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1450889 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1452810 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1433941 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456030 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456709 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1434170 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456036 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456702 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1434904 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1452521 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1454028 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1435128 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1435169 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1435561 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456142 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456004 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1435584 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1465737 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1435608 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456020 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1465583 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1437053 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1518920 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1437102 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1437102 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1466302 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1455401 | SOURCEANDSINK | PIPE | HEATING | HVL 1
Port_1439442 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1439442 | SOURCEANDSINK | PIPE | HEATING | HVL 2
OutPort_1457511 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1439442 | SOURCEANDSINK | PIPE | HEATING | HRL 2
OutPort_1457548 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1439570 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1457359 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1457624 | SOURCEANDSINK | PIPE | HEATING | HRL 2
InPort_1439598 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458325 | SOURCEANDSINK | PIPE | HEATING | HRL 2
InPort_1439622 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458422 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1440187 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456195 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1449395 | SINK | PIPE | HEATING | HVL 1
OutPort_1451811 | SOURCE | PIPE | HEATING | HVL 1
InPort_1451835 | SINK | PIPE | HEATING | HRL 1
OutPort_1449395 | SOURCE | PIPE | HEATING | HRL 1
InPort_1449810 | SINK | PIPE | HEATING | HVL 1
OutPort_1465533 | SOURCE | PIPE | HEATING | HVL 1
InPort_1465413 | SINK | PIPE | HEATING | HRL 1
OutPort_1449810 | SOURCE | PIPE | HEATING | HRL 1
InPort_1449833 | SINK | PIPE | HEATING | HRL 1
OutPort_1449828 | SOURCE | PIPE | HEATING | HRL 1
InPort_1449828 | SINK | PIPE | HEATING | HVL 1
OutPort_1449829 | SOURCE | PIPE | HEATING | HVL 1
InPort_1449829 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1527834 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1449833 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1466454 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1449835 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1527826 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1450959 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1515613 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1515576 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1451430 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1515545 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1451508 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1451811 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1518930 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1451835 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518893 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1453209 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1453426 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1453426 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1466243 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1453493 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518897 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1453545 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1455669 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1455505 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1455401 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1455445 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1455445 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456031 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1455505 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1518650 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1455506 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1455506 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1466242 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1455669 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456037 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1455760 | SINK | PIPE | HEATING | HVL 1
OutPort_1455825 | SOURCE | PIPE | HEATING | HVL 1
InPort_1455827 | SINK | PIPE | HEATING | HRL 1
OutPort_1455760 | SOURCE | PIPE | HEATING | HRL 1
InPort_1455762 | SINK | PIPE | HEATING | HVL 1
OutPort_1455847 | SOURCE | PIPE | HEATING | HVL 1
InPort_1455849 | SINK | PIPE | HEATING | HRL 1
OutPort_1455762 | SOURCE | PIPE | HEATING | HRL 1
2 x InPort_1455821 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1514847 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1455825 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1455827 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1514824 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1455831 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1455843 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456429 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1514888 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1455847 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1455849 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1514871 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1455853 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456567 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1456004 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1456005 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1456005 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1456020 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1456021 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1456021 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1456030 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1456036 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1456323 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1466458 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1456348 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1527832 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1456429 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1456713 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1456430 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1456476 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1466443 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1456567 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1456691 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1456568 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1456887 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1457143 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458430 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1456971 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458432 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1457002 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458333 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1457068 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1457658 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1457143 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458090 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1457224 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458086 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1457263 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458250 | SOURCEANDSINK | PIPE | HEATING | HRL 2
InPort_1457304 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1458047 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1457359 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458262 | SOURCEANDSINK | PIPE | HEATING | HRL 2
InPort_1457511 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x OutPort_1457668 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1457548 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1457635 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1457622 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1457656 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1458039 | SOURCEANDSINK | PIPE | HEATING | HVL 2
2 x InPort_1458170 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458264 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1458186 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458266 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1458203 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1458312 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x OutPort_1458329 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1458323 | SOURCEANDSINK | PIPE | HEATING | HRL 2
2 x InPort_1458420 | SOURCEANDSINK | PIPE | HEATING | HVL 2
InPort_1463746 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
2 x OutPort_1463745 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464066 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1463745 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509559 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579176 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1463746 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464258 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464042 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464042 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464070 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464070 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464066 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464247 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464258 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464341 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464247 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579333 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464333 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1464333 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1464341 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1465413 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1465652 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1465533 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1465631 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1465558 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1465644 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1465741 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1465692 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1465875 | SINK | PIPE | HEATING | HRL 1
OutPort_1465808 | SOURCE | PIPE | HEATING | HRL 1
InPort_1465808 | SINK | PIPE | HEATING | HVL 1
OutPort_1465844 | SOURCE | PIPE | HEATING | HVL 1
InPort_1465844 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1466309 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1465875 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1466254 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1466240 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518827 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1466242 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1466254 | SOURCEANDSINK | PIPE | HEATING | HRL 1
OutPort_1518815 | SOURCEANDSINK | PIPE | HEATING | HRL 1
3 x InPort_1466301 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1518732 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1466309 | SOURCEANDSINK | PIPE | HEATING | HVL 1
OutPort_1518777 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1466439 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1466445 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1466440 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1527828 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1494839 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1476981 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_1501923 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1484360 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1494498 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494674 | SOURCE | DUCT | VENTILATION | ETA 1
3 x InPort_1494727 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1494498 | SOURCE | DUCT | VENTILATION | ETA 1
2 x InPort_1494674 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494897 | SOURCE | DUCT | VENTILATION | ETA 1
OutPort_1494941 | SOURCE | DUCT | VENTILATION | ETA 1
OutPort_1501955 | SOURCE | DUCT | EXHAUST | ETA 1
OutPort_1494850 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1494859 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1494839 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1494846 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1494859 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1494850 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1494846 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1494886 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494875 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_1494905 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494886 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_1494897 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494893 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_1494893 | SINK | DUCT | VENTILATION | ETA 1
OutPort_1494905 | SOURCE | DUCT | VENTILATION | ETA 1
InPort_1501955 | SINK | DUCT | EXHAUST | ETA 1
OutPort_1501923 | SOURCE | DUCT | EXHAUST | ETA 1
InPort_1503805 | SINK | PIPE | SEWAGE | RW 1
OutPort_1503360 | SOURCE | PIPE | SEWAGE | RW 1
InPort_1504090 | SINK | PIPE | SEWAGE | RW 1
OutPort_1503369 | SOURCE | PIPE | SEWAGE | RW 1
InPort_1504291 | SINK | PIPE | SEWAGE | RW 1
OutPort_1503386 | SOURCE | PIPE | SEWAGE | RW 1
2 x InPort_1503785 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1519176 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1519182 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
InPort_1503805 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
OutPort_1503809 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
InPort_1503809 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1504104 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
InPort_1504090 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
OutPort_1504103 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1504103 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1519183 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
InPort_1504291 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1504352 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1504304 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1504356 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1504346 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1504434 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x OutPort_1519186 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
OutPort_1505236 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
InPort_1505236 | SINK | PIPE | SEWAGE | RW 1
OutPort_1504535 | SOURCE | PIPE | SEWAGE | RW 1
InPort_1504535 | SINK | PIPE | SEWAGE | RW 1
OutPort_1505150 | SOURCE | PIPE | SEWAGE | RW 1
InPort_1504858 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1505141 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1505112 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1505141 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
OutPort_1505150 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1505150 | SINK | PIPE | SEWAGE | SW 1
OutPort_1504535 | SOURCE | PIPE | SEWAGE | SW 1
InPort_1506077 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1505259 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1506080 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1505274 | SOURCE | DUCT | VENTILATION | ETA 2
2 x InPort_1505756 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1551834 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1506598 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1505756 | SOURCE | DUCT | VENTILATION | ETA 2
OutPort_1506080 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1505828 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1551836 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1551834 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1505828 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1508104 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1506077 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1506589 | SINK | DUCT | EXHAUST | ETA 2
OutPort_1506148 | SOURCE | DUCT | EXHAUST | ETA 2
Port_1506589 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1551734 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1506598 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1508025 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1507752 | SOURCE | DUCT | USERDEFINED | ETA 2
Port_1507752 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_1507752 | SINK | DUCT | USERDEFINED | ETA 2
OutPort_1508104 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1551836 | SINK | DUCT | VENTILATION | ETA 2
OutPort_1508025 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1509111 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x OutPort_1509115 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
2 x InPort_1509112 | SOURCEANDSINK | PIPE | SEWAGE | SW 1
InPort_1509559 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509597 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509566 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1509694 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1509597 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509600 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509600 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509623 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509623 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509617 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509617 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509635 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509635 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509627 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509627 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509643 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
Port_1509637 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1509643 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1509637 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1509681 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1509702 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1509702 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
OutPort_1509706 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1509706 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1509729 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1509721 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1509737 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
Port_1509731 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1509731 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1518642 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1518934 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1518650 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518885 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1518732 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1518791 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1518752 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518831 | SOURCEANDSINK | PIPE | HEATING | HRL 1
InPort_1518777 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x OutPort_1518781 | SOURCEANDSINK | PIPE | HEATING | HVL 1
2 x InPort_1518778 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1518815 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x OutPort_1518819 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1518816 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1518883 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1518918 | SOURCEANDSINK | PIPE | HEATING | HVL 1
InPort_1519182 | SOURCEANDSINK | PIPE | SEWAGE | RW 1
2 x InPort_1527786 | SOURCEANDSINK | PIPE | HEATING | HRL 1
2 x InPort_1527808 | SOURCEANDSINK | PIPE | HEATING | HVL 1
Port_1551734 | SOURCE | DUCT | VENTILATION | ETA 2
InPort_1567361 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567417 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567417 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567405 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567405 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567425 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567419 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567441 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567425 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567419 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567427 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567439 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1567441 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1567427 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1579478 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1570151 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1570151 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579474 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1570163 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1570273 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1579472 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1570187 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
InPort_1570187 | SINK | PIPE | DOMESTICCOLDWATER | TWK 1
OutPort_1579478 | SOURCE | PIPE | DOMESTICCOLDWATER | TWK 1
2 x InPort_1570238 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
InPort_1575261 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1575375 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1575359 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1575383 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1575377 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x OutPort_1575399 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1
2 x InPort_1575385 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | TWW 1

# IfcDistributionSystem: 120_L_ETA (2)
PredefinedType: VENTILATION
Name
ETA 1
ETA 2

# IfcDistributionSystem: BIMA+_Generic_DrinkingWaterCold, TWW 1
PredefinedType: DOMESTICHOTWATER

# IfcDistributionSystem: BIMA+_Generic_DrinkingWaterWarm, TWK 1
PredefinedType: DOMESTICCOLDWATER

# IfcDistributionSystem: BIMA+_Generic_HeatingReturn (2)
PredefinedType: HEATING
Name
HRL 1
HRL 2

# IfcDistributionSystem: BIMA+_Generic_HeatingSupply (2)
PredefinedType: HEATING
Name
HVL 1
HVL 2

# IfcDistributionSystem: BIMA+_Generic_Rainwater, RW 1
PredefinedType: SEWAGE

# IfcDistributionSystem: BIMA+_Generic_Sewage, SW 1
PredefinedType: SEWAGE

# IfcDuctFitting: BIMA+_Generic_Rectangular_to_Round_Transition_-_Angle:45 Degree (2)
Type - PredefinedType: TRANSITION; Classification: Pr_65_65_25_72 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Rectangular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_72 Number of the classified element (Number)
Name (BIMA+_Generic_Rectangular_to_Round_Transition_-_Angle:45 Degree:...) | In | Group
1501955 | Level 2 | ETA 1
1506598 | 3 | ETA 2

# IfcDuctFitting: BIMA+_Generic_Round_Elbow:1 D (3)
Type - PredefinedType: BEND; Classification: Pr_65_65_25_14 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Circular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_14 Number of the classified element (Number)
Name (BIMA+_Generic_Round_Elbow:1 D:...) | In | Group
1494859 | Level 1 | ETA 1
1494905 | Level 1 | ETA 1
1551836 | 3 | ETA 2

# IfcDuctFitting: BIMA+_Generic_Round_Endcap:Standard, BIMA+_Generic_Round_Endcap:Standard:1494941
In: Level 2
Type - PredefinedType: OBSTRUCTION; Classification: Pr_65_65_25_14 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Circular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_14 Number of the classified element (Number); Group: ETA 1

# IfcDuctFitting: BIMA+_Generic_Round_Takeoff:Standard (2)
In: Level 1
Type - PredefinedType: CONNECTOR; Classification: Pr_65_65_25_14 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Circular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_14 Number of the classified element (Number); Group: ETA 1
Name (BIMA+_Generic_Round_Takeoff:Standard:...)
1494850
1494897

# IfcDuctFitting: BIMA+_Generic_Round_Takeoff:Standard, BIMA+_Generic_Round_Takeoff:Standard:1551834
In: 3
Type - PredefinedType: JUNCTION; Classification: Pr_65_65_25_14 Number of the classified element (Number); Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Circular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_14 Number of the classified element (Number); Group: ETA 2

# IfcDuctSegment: Flex Duct Round:Flex - Round (2)
In: Level 1
Type - PredefinedType: FLEXIBLESEGMENT; Material: BIMA+_120_L_ETA
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Flexible ductwork Title of the classified element (Title); Pr_65_65_25_32 Number of the classified element (Number); Group: ETA 2
PSet_DuctSegmentTypeCommon - DuctShape: Round; NominalDiameterOrWidth: 100 mm
Name (Flex Duct Round:Flex - Round:...) | Length (mm)
1506077 | 356.847
1506080 | 356.89

# IfcDuctSegment: Rectangular Duct:Radius Elbows / Taps (3)
Type - PredefinedType: RIGIDSEGMENT; Material: BIMA+_120_L_ETA
Type - IfcRoot - IfcDescription: Duct Segment
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Rectangular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_72 Number of the classified element (Number)
PSet_DuctSegmentOccurence - HasLiner: yes; InteriorRoughnessCoefficient: 0; Color: Grey
PSet_DuctSegmentTypeCommon - DuctShape: Rectangular
Name (Rectangular Duct:Radius Elbows / Taps:...) | In | Length (mm) | GrossCrossSectionArea (m2) | Group
1501923 | Level 2 | 243.881 | 0.365822 | ETA 1
1506589 | Level 1 | 77 | 0.0847 | ETA 2
1551734 | Level 1 | 302.19 | 0.332409 | ETA 2

# IfcDuctSegment: Round Duct:Taps / Short Radius (10)
Type - PredefinedType: RIGIDSEGMENT; Material: BIMA+_120_L_ETA
Type - IfcRoot - IfcDescription: A duct segment is used to typically join two sections of duct network.A duct segment is used to typically join two sections of duct network.A duct segment is used to typically join two sections of duct network.A duct segment is used to typically join two sections of duct network.
Type - PSet_ManufacturerTypeInformation - Manufacturer: Generic
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Circular sheet metal ductwork and fittings Title of the classified element (Title); Pr_65_65_25_14 Number of the classified element (Number)
PSet_DuctSegmentOccurence - HasLiner: yes; Color: Grey
Name (Round Duct:Taps / Short Radius:...) | In | InteriorRoughnessCoefficient | DuctShape | NominalDiameterOrWidth (mm) | Length (mm) | GrossCrossSectionArea (m2) | Group
1494674 | Level 2 | 0 | Round | 310 | 420 | 0.409035 | ETA 1
1494727 | Level 2 | 0 | Round | 310 | 313.966 | 0.30577 | ETA 1
1494839 | Level 1 | 0 | Round | 100 | 245 | 0.076969 | ETA 1
1494846 | Level 1 | 0 | Round | 100 | 30.3847 | 0.00954564 | ETA 1
1494886 | Level 1 | 0 | Round | 100 | 245 | 0.076969 | ETA 1
1494893 | Level 1 | 0 | Round | 100 | 30.4084 | 0.00955309 | ETA 1
1505756 | Level 1 | 1 | Round | 100 | 1184.56 | 0.372141 | ETA 2
1505828 | Level 1 | 0 | Round | 100 | 838.24 | 0.263341 | ETA 2
1508025 | Level 1 | 0 | Round | 100 | 211.991 | 0.0665988 | ETA 2
1508104 | Level 2 | 0 |  | 100 | 568.009 | 0.178445 | ETA 2

# IfcFan: BIMA+_Aereco_AxialFan_EGPAML:EGP.AML.31.2.0.75, BIMA+_Aereco_AxialFan_EGPAML:EGP.AML.31.2.0.75:1494498
In: Level 2
Type - PredefinedType: PROPELLORAXIAL; Classification: Pr_65_67_29_05 Number of the classified element (Number); Material: BIMA+_Stal nierdzewna
Type - IfcRoot - IfcDescription: Axial Fan
Type - PSet_ManufacturerTypeInformation - Manufacturer: AERECO wentylacja sp.zo.o.
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Axial flow fans Title of the classified element (Title); Pr_65_67_29_05 Number of the classified element (Number); Group: ETA 1

# IfcFan: BIMA+_Infiniair_AxialFan_DuctMounted:Diameter_100, BIMA+_Infiniair_AxialFan_DuctMounted:Diameter_100:1507752
In: 3
Type - PredefinedType: PROPELLORAXIAL; Classification: Pr_65_67_29_05 Number of the classified element (Number); Material: BIMA+_nbl_ConceptWhite, BIMA+_nbl_ClearanceZone
Type - IfcRoot - IfcDescription: Axial Fan
Type - PSet_ManufacturerTypeInformation - Manufacturer: Infiniair
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Axial flow fans Title of the classified element (Title); Pr_65_67_29_05 Number of the classified element (Number); Group: ETA 2

# IfcPipeFitting: BIMA+_Generic_Bend_Copper:Standard, BIMA+_Generic_Bend_Copper:Standard:1450889
In: Level 1
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_200_H_VL
Classification: Uniclass 2015 Title (ClassificationName); Products Table used for element classification (Table); 1.28 Version of the table used for element classification (Version); Stainless steel pipe fittings Title of the classified element (Title); Pr_65_52_63_79 Number of the classified element (Number); Group: HVL 1

# IfcPipeFitting: BIMA+_Generic_Bend_Copper:Standard, BIMA+_Generic_Bend_Copper:Standard:1456142
In: Level 2
Type - PredefinedType: BEND; Classification: Pr_65_52_63_79 Number of the classified element (Number); Material: BIMA+_201_H_RL
